## config/boards/shields/custom/Kconfig.defconfig
```kconfig
if SHIELD_CUSTOM

    config ZMK_KEYBOARD_NAME
    default "Dhillon Keyboard"

endif
```
